## src/Kconfig
```kconfig
menu "Linux Memory Extractor"

config LIME
    bool "Enable LiME support"
    default m
    help
        This option enables LiME as a module.

endmenu
```
